# IAR project door_ring.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; App; Bsp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: JX-GDZWBXX.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Bsp/: main.h
  group App
    App/: global_variable.c main.c stm8s_it.c
  group Bsp
    Bsp/: bsp.c eeprom.c timer.c uart.c
  group Doc
    Doc/: ReadMe.txt
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
