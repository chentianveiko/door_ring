# IAR project door_ring.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\app; ..\hw; ..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: door_ring.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../app/: app.c global_variable.c main.c stm8s_it.c
  group app/inc
    ../app/: app.h global_define.h global_variable.h stm8s_conf.h stm8s_it.h
  group hw
    ../hw/: hw_board.c hw_usart.c
  group hw/inc
    ../hw/: hw_board.h hw_mcu.h hw_usart.h
  group std_periph
    ../STM8S_StdPeriph_Driver/src/: stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c
